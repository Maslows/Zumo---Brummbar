# Keil uVision project Brummbar.uvprojx, settings and files
target CMSIS-DAP (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Brummbar
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group RTX
    ./: main.c osObjects.h Comms.c
  group Peripherials
    ./: servo.c servo.h sonar.c sonar.h motors.c motors.h
  group Comms
    ./: bluetooth.c bluetooth.h
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/MKL46Z256xxx4/: startup_MKL46Z4.s system_MKL46Z4.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Startup 1.0.0
